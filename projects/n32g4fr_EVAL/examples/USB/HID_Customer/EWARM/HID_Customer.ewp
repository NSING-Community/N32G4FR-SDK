# IAR project HID_Customer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G4FRME Nations N32G4FRME
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G4FR; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT=1; __IAR_ARM
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc; ..\..\..\..\..\..\firmware\n32g4fr_usbfs_driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_Customer.bin
  ILINK.IlinkOutputFile: HID_Customer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_dac.c n32g4fr_dma.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_tim.c n32g4fr_usart.c
  group n32g4fr_usbfs_driver
    ../../../../../../firmware/n32g4fr_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr_EWARM.s
  group USER
    ../src/: hw_config.c main.c n32g4fr_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
