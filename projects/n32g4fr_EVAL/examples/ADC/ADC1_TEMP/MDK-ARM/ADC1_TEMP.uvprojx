# Keil uVision project ADC1_TEMP.uvprojx, settings and files
target N32G4FR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.1.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC1_TEMP
  AfterMake: fromelf --bin --output=.\bin\ADC1_TEMP.bin .\Objects\ADC1_TEMP.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,__FPU_PRESEN,DEFINEFLOAT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_adc.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c n32g4fr_dma.c n32g4fr_dbg.c
  group USER
    ../src/: main.c n32g4fr_it.c
  group DOC
    ../: readme.txt
